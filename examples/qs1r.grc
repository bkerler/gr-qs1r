options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '262144'
  states: {}
- name: qs1r_qs1r_src_0
  id: qs1r_qs1r_src
  parameters:
    dith_flag: 'False'
    frequency: '10000000'
    pga_flag: 'True'
    ppm: '0'
    rand_flag: 'True'
    samplerate: '125000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT Plot"'
    type: complex
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_int_to_float_0, '0', blocks_deinterleave_0, '0']
- [qs1r_qs1r_src_0, '0', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-774-gce0c68c0
